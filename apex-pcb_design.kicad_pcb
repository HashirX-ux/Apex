# Repository HashirX-ux/Apex

File README.md:

# Apex

`

---

## What is it?

## CAD

Apex is a custom **112 key full size** wireless mechanical keyboard I designed from the ground up after building a macropad and deciding a store bought board would never feel like mine.

The PCB is designed in **KiCad**, the case in **FreeCAD**, and the firmware is on **ZMK**. 

On top of a standard full size layout it adds:

- a **0.91" SSD1306 OLED** (128×32, I²C) for layer / battery / connection status
- an **EC11 rotary encoder** with push switch (volume and extras)
- an onboard **buzzer** driven by a 2N3904
- **per-key SK6812 Mini E** reverse mount RGB

---

## Why I built it

I wanted a Keyboard that belongs to me not to any company so I build my own keyboard. 

---

## Features

- 112 keys, full size layout (ANSI 104 + 8 extra keys)
- 8×14 col2row matrix
- Wireless BLE 5.0 via Nordic nRF52840 (AQFN- 73)
- USB C wired + wireless dual mode
- Per-key SK6812 Mini E RGB, reverse mounted
- Kailh MX hot-swap sockets  
- 0.91" OLED (SSD1306, 128×32, I²C)
- EC11 rotary encoder with push switch
- Onboard buzzer (2N3904 driver)
- 3.7 V LiPo 1500 mAh with MCP73831 charger
- 74AHCT125 level shifter for LED data (3.3 V → 5 V)
- USBLC6 2SC6 ESD protection on USB D+/D−
- 32 MHz crystal for the nRF52840
- ZMK firmware (USB + BLE, battery reporting, OLED, encoder, RGB)
- 2-layer PCB, KiCad, JLCPCB fabrication
- Custom 3D printed case designed in FreeCAD

---

ZMK is currently targeted at `nice_nano_v2` as a bring up stand in. The PCB carries a **bare nRF52840** (not a Pro Micro module). Pin mapping on the real board is still being finished see [Firmware](#flash-the-firmware).

---

## How to Build

### Order the PCB

1. Go to [JLCPCB](https://jlcpcb.com)
2. Upload the Gerbers from `pcb/gerber/gerber.rar`
3. 2-layer, FR 4, **1.6 mm**, HASL or **ENIG** (ENIG recommended for hot-swap pads and the AQFN-73)
4. Minimum order is 5 boards
5. Order a stencil for the nRF52840, SK6812 Mini-E, and other SMD parts the AQFN-73 is not a hand-solder-first footprint

### Flash the Firmware

Firmware lives in [`frimware/`](frimware/) and is a **ZMK skeleton**, not the final keymap.

1. Fork this repo (or copy `frimware/` into a [ZMK config](https://zmk.dev/docs/user-setup) repo)
2. Current build target in `frimware/build.yaml`:

   ```yaml
   include:
     - board: nice_nano_v2
       shield: apex
   ```

3. Edit the keymap at `frimware/config/apex.keymap`
4. Push GitHub Actions builds the `.uf2`
5. Download the artifact, double-tap reset to enter the bootloader, drag the `.uf2` onto the drive that appears

The overlay (`frimware/config/boards/shields/apex/apex.overlay`) is still a 5×14 bring up matrix. The PCB is **8×14 / 112 keys**. Next step is mapping the real nRF52840 pins, OLED, encoder, buzzer, and the 112 LED chain.

## BOM

> Estimated total: **~$230 USD** can drop to **$170–$200** buying locally and skipping extras (second switch pack, spare LEDs, extra PCBs).

Prices are typical AliExpress pack prices as of 2026. You buy the pack; you do not need every piece in it. Shipping not included.

| Component | Spec | Qty | Price | Notes | Link |
|---|---|---|---|---|---|
| Microcontroller | nRF52840-QIAA, AQFN-73 | ×1 | $5.00 | Bare Nordic SoC — BLE 5.0, 7×7 mm | [Buy](https://www.aliexpress.com/item/1005009698070392.html) |
| 74AHCT125 level shifter | TSSOP-14 | ×1 | $2.52 | Pack of 10 — LED data 3.3 V → 5 V | [Buy](https://www.aliexpress.com/item/1005008171122183.html) |
| MCP73831 LiPo charger | MCP73831-2-MC, DFN-8 3×2 mm | ×1 | $2.50 | Pack of 10 — **DFN-8 footprint**, not SOT-23-5 | [Buy](https://www.aliexpress.com/item/1005007439657191.html) |
| USBLC6-2SC6 ESD | SOT-23-6 | ×1 | $1.50 | Pack of 10 — USB D+/D− | [Buy](https://www.aliexpress.com/item/32807108222.html) |
| MX mechanical switches | 5-pin PCB mount | ×112 | $32.00 | Pack of 110–120 — Gateron / any MX 5-pin | [Buy](https://www.aliexpress.com/item/1005006091988869.html) |
| Kailh hot-swap socket | MX compatible, CPG151101S11 | ×112 | $14.00 | Pack of 100 × 2 | [Buy](https://www.aliexpress.com/item/1005006105603269.html) |
| SK6812 Mini-E RGB LED | Reverse mount, 3.2×2.8 mm | ×112 | $27.00 | Pack of 100 × 2 — buy 200, use 112 + spares | [Buy](https://www.aliexpress.com/item/1005004249903121.html) |
| 1N4148W matrix diode | SOD-123 | ×112 | $3.00 | Pack of 100 × 2 | [Buy](https://www.aliexpress.com/item/1005010728396328.html) |
| EC11 rotary encoder | 20 mm, with push switch | ×1 | $2.00 | Pack of 5 | [Buy](https://www.aliexpress.com/item/1005006460161288.html) |
| Rotary knob | Aluminum, 6 mm D-shaft, 20 mm | ×1 | $2.00 | 2 pieces | [Buy](https://www.aliexpress.com/item/4001091267351.html) |
| Reset button | SMD tactile, CK KMR2 | ×1 | $1.50 | Pack of 30 | [Buy](https://www.aliexpress.com/item/4001107416458.html) |
| OLED display | 0.91" 128×32 SSD1306 I²C | ×1 | $2.50 | ER-OLED0.91, address 0x3C | [Buy](https://www.aliexpress.com/item/1005004375650245.html) |
| Buzzer | 12×9.5 mm, 5 V | ×1 | $1.80 | Pack of 10 — matches 12×9.5 RM7.6 footprint | [Buy](https://www.aliexpress.com/item/4000829554492.html) |
| 2N3904 transistor | TO-92 | ×1 | $1.40 | Pack of 50 — buzzer driver | [Buy](https://www.aliexpress.com/w/wholesale-2n3904-transistor.html) |
| 32 MHz crystal | SMD 2016, 4-pin | ×1 | $1.80 | Pack of 10 — nRF52840 HFCLK | [Buy](https://www.aliexpress.com/w/wholesale-32mhz-crystal.html) |
| Status LED | 0603 SMD | ×1 | $1.00 | Pack of 100 — charger / power indicator | [Buy](https://www.aliexpress.com/w/wholesale-0603-smd-led.html) |
| Resistor 10 kΩ | 0603 | ×3 | $1.20 | Pack of 300 — I²C / reset pull-ups | [Buy](https://www.aliexpress.com/item/1005011779883974.html) |
| Resistor 5.1 kΩ | 0603 | ×2 | $1.30 | Pack of 300 — USB-C CC1/CC2 | [Buy](https://www.aliexpress.com/item/1005011779883974.html) |
| Resistor 330 Ω | 0603 | ×1 | $2.00 | Pack of 500 — buzzer base / LED | [Buy](https://www.aliexpress.com/item/1005005700395390.html) |
| Resistor 1 kΩ | 1206 + 0805 | ×2 | $1.20 | Pack of 300 — PROG / current limit | [Buy](https://www.aliexpress.com/item/1005011779883974.html) |
| Capacitor 100 nF | 0805 | ×119 | $2.00 | Pack of 200 — 112 LED + MCU decoupling | [Buy](https://www.aliexpress.com/item/1005007660078779.html) |
| Capacitor 12 pF | 0402 | ×2 | $1.50 | Pack of 100 — crystal load | [Buy](https://www.aliexpress.com/w/wholesale-0402-12pf-capacitor.html) |
| USB-C receptacle 16P | GCT USB4105 SMD | ×1 | $4.50 | Pack of 5 | [Buy](https://www.aliexpress.com/item/1005005581945089.html) |
| JST PH 2-pin | PH2.0, B2B-PH-K vertical | ×1 | $2.00 | Pack of 2 — battery connector | [Buy](https://www.aliexpress.com/item/1005010615395743.html) |
| Polyfuse 500 mA | Resettable, 1206 | ×1 | $1.70 | Pack of 10 | [Buy](https://www.aliexpress.com/item/1005005235906949.html) |
| LiPo 3.7 V 1500 mAh | JST PH 2.0 | ×1 | $5.80 | Size to fit the case tray | [Buy](https://www.aliexpress.com/item/1005010110802624.html) |
| Keycap set | PBT, full-size MX | ×104+ | $26.00 | 104-key set; extras needed for 112 | [Buy](https://www.aliexpress.com/w/wholesale-104-keycap-set.html) |
| PCB fabrication | 2-layer, FR-4, 1.6 mm, HASL/ENIG | ×5 boards | $32.00 | Full-size board — ENIG preferred | [JLCPCB](https://cart.jlcpcb.com/quote) |
| 3D print — case | FDM PETG / SLA resin | ×1 | $42.00 | FreeCAD sources in `cad/` — local print is cheaper | [JLC3DP](https://jlc3dp.com/3d-printing-quote) |
| M3 screws | M3 × 8 mm countersunk | ×10 | $1.00 | Pack of 50 | [Buy](https://www.aliexpress.com/item/1005008810897680.html) |
| M3 standoffs | M3 × 4–6 mm | ×10 | $1.00 | Pack of 50 | [Buy](https://www.aliexpress.com/item/1005008810897680.html) |

**BOM notes**

- The charger footprint on the PCB is **DFN-8 (MCP73831-2-MC)**. A SOT-23-5 MCP73831 will not fit without a bodge.
- SK6812 Mini-E must be the **reverse-mount** Mini-E, not SK6812 Mini or WS2812B 3535.
- Hot-swap sockets are **Kailh MX** (CPG151101S11), 1.00u. Stabilizers are still required on 2U+ keys (not listed — use your usual plate/PCB mount Cherry-style stabs).
- nRF52840 can run from VDDH (2.5–5.5 V high-voltage mode), which is why there is no separate 3.3 V LDO on this rev. LEDs are 5 V (`LED_5V` / VBUS).
- PROG resistor on the MCP73831 sets charge current (`IREG ≈ 1000 / RPROG`). 1 kΩ ≈ 1 A; 2 kΩ ≈ 500 mA. 500 mA is gentler on a 1500 mAh cell.

---

## Repository

```text
Apex/
├── cad/                  FreeCAD case + STEP
│   ├── APex cad.FCStd
│   └── .step
├── frimware/             ZMK config (skeleton)
│   ├── build.yaml
│   └── config/
│       ├── apex.conf
│       ├── apex.keymap
│       └── boards/shields/apex/
├── pcb/
│   ├── apex-pcb_design.kicad_sch
│   ├── apex-pcb_design.kicad_pcb
│   ├── LED-Design.kicad_sch
│   └── gerber/gerber.rar
├── Journal.md            Build log
└── LICENSE               MIT
```

---

## Credits

- [KiCad](https://www.kicad.org/)   PCB design
- [ZMK Firmware](https://zmk.dev/)   open-source wireless keyboard firmware
- [FreeCAD](https://www.freecad.org/)  case design
- [Nordic Semiconductor](https://www.nordicsemi.com/)   nRF52840
- [nice!nano](https://nicekeyboards.com/nice-nano/)   ZMK bring-up target
- Guides that got this off the ground: [nice!nano docs](https://nicekeyboards.com/docs/nice-nano/), [JLCPCB keyboard PCB guide](https://jlcpcb.com/blog/pcb-keyboards-design-guide), [Masterzen keyboard design series](https://www.masterzen.fr/2020/05/03/designing-a-keyboard-part-1/)

Made by **Hashir**  2026

---

## License

[MIT](LICENSE)

## KiCad design apex-pcb_design.kicad_pcb

Schematic: apex-pcb_design.kicad_sch

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C2: 12pF; C_0402_1005Metric
C3, C4, C5, C6, C7, C8, C121: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112: 1N4148; D_SOD-123
D113: LED; LED_0603_1608Metric
D115: SK6812MINI-E; LED_SK6812MINI-E_3.2x2.8mm_P1.5mm_ReverseMount
F1: 500mA; Fuse_1206_3216Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: 1500mAh; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
Q1: 2N3904; TO-92_Inline
R1, R2, R8: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 1k; R_1206_3216Metric
R9: 1k; R_0805_2012Metric
R10: 330R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW55, SW56, SW57, SW58, SW59, SW60, SW61, SW62, SW63, SW64, SW65, SW66, SW67, SW68, SW69, SW70, SW71, SW72, SW73, SW74, SW75, SW76, SW77, SW78, SW79, SW80, SW81, SW82, SW83, SW84, SW85, SW86, SW87, SW88, SW89, SW90, SW91, SW92, SW93, SW94, SW95, SW96, SW97, SW98, SW99, SW100, SW101, SW102, SW103, SW104, SW105, SW106, SW107, SW108, SW109, SW110, SW111, SW112: SW_Push; SW_Hotswap_Kailh_MX_1.00u
SW113: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm_MountingHoles
SW114: SW_Push; SW_Push_1P1T_NO_CK_KMR2
U1: ER_OLEDM0.91_1x-I2C
U2: USBLC6-2SC6; SOT-23-6
U3: MCP73831-2-MC; DFN-8-1EP_3x2mm_P0.5mm_EP1.7x1.4mm
U4: nRF52840; Nordic_AQFN-73-1EP_7x7mm_P0.5mm
U5: 74AHCT125; TSSOP-14_4.4x5mm_P0.65mm
Y1: 32MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3.3V: BZ1.1 (+), C5.1, C6.1, C7.1, C8.1, C121.1, R1.1, R2.1, U1.2 (VCC), U4.A22 (VDD), U4.AD14 (VDD), U4.AD23 (VDD), U4.B1 (VDD), U4.W1 (VDD)
BUZZER: BZ1.2 (-), Q1.3 (C)
COL0: SW1.2, SW15.2, SW29.2, SW43.2, SW57.2, SW71.2, SW85.2, SW99.2, U4.AD8 (P0.13)
COL1: SW2.2, SW16.2, SW30.2, SW44.2, SW58.2, SW72.2, SW86.2, SW100.2, U4.AC9 (P0.14)
COL2: SW3.2, SW17.2, SW31.2, SW45.2, SW59.2, SW73.2, SW87.2, SW101.2, U4.AD10 (P0.15)
COL3: SW4.2, SW18.2, SW32.2, SW46.2, SW60.2, SW74.2, SW88.2, SW102.2, U4.AC11 (P0.16)
COL4: SW5.2, SW19.2, SW33.2, SW47.2, SW61.2, SW75.2, SW89.2, SW103.2, U4.AD12 (P0.17)
COL5: SW6.2, SW20.2, SW34.2, SW48.2, SW62.2, SW76.2, SW90.2, SW104.2, U4.AC15 (P0.19)
COL6: SW7.2, SW21.2, SW35.2, SW49.2, SW63.2, SW77.2, SW91.2, SW105.2, U4.AD16 (P0.20)
COL7: SW8.2, SW22.2, SW36.2, SW50.2, SW64.2, SW78.2, SW92.2, SW106.2, U4.AC17 (P0.21)
COL8: SW9.2, SW23.2, SW37.2, SW51.2, SW65.2, SW79.2, SW93.2, SW107.2, U4.AD18 (P0.22)
COL9: SW10.2, SW24.2, SW38.2, SW52.2, SW66.2, SW80.2, SW94.2, SW108.2, U4.AC19 (P0.23)
COL10: SW11.2, SW25.2, SW39.2, SW53.2, SW67.2, SW81.2, SW95.2, SW109.2, U4.AD20 (P0.24)
COL11: SW12.2, SW26.2, SW40.2, SW54.2, SW68.2, SW82.2, SW96.2, SW110.2, U4.AC21 (P0.25)
COL12: SW13.2, SW27.2, SW41.2, SW55.2, SW69.2, SW83.2, SW97.2, SW111.2, U4.G1 (P0.26)
COL13: SW14.2, SW28.2, SW42.2, SW56.2, SW70.2, SW84.2, SW98.2, SW112.2, U4.H2 (P0.27)
ENC_A: R1.2, SW113.A, U4.A20 (P1.10)
ENC_B: R2.2, SW113.B, U4.B19 (P1.11)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C121.2, D115.1 (VSS), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.2, Q1.1 (E), R5.2, R6.2, R7.2, R8.1, SW113.C, SW114.1, U1.1 (GND), U2.2 (GND), U3.6 (V_{SS}), U4.B7 (VSS), U4.EP (VSS), U4.F23 (VSS_PA), U5.1, U5.7 (GND), Y1.2; also elsewhere on the board
LED_5V: R10.1, U5.3
LED_DATA_3V3: U4.R1 (TRACEDATA3/P1.09), U5.2
unnamed: D1.2 (A), SW1.1
unnamed: D2.2 (A), SW2.1
unnamed: D3.2 (A), SW3.1
unnamed: D4.2 (A), SW4.1
unnamed: D5.2 (A), SW5.1
unnamed: D6.2 (A), SW6.1
unnamed: D7.2 (A), SW7.1
unnamed: D8.2 (A), SW8.1
unnamed: D9.2 (A), SW9.1
unnamed: D10.2 (A), SW10.1
unnamed: D11.2 (A), SW11.1
unnamed: D12.2 (A), SW12.1
unnamed: D13.2 (A), SW13.1
unnamed: D14.2 (A), SW14.1
unnamed: D15.2 (A), SW15.1
unnamed: D16.2 (A), SW16.1
unnamed: D17.2 (A), SW17.1
unnamed: D18.2 (A), SW18.1
unnamed: D19.2 (A), SW19.1
unnamed: D20.2 (A), SW20.1
unnamed: D21.2 (A), SW21.1
unnamed: D22.2 (A), SW22.1
unnamed: D23.2 (A), SW23.1
unnamed: D24.2 (A), SW24.1
unnamed: D25.2 (A), SW25.1
unnamed: D26.2 (A), SW26.1
unnamed: D27.2 (A), SW27.1
unnamed: D28.2 (A), SW28.1
unnamed: D29.2 (A), SW29.1
unnamed: D30.2 (A), SW30.1
unnamed: D31.2 (A), SW31.1
unnamed: D32.2 (A), SW32.1
unnamed: D33.2 (A), SW33.1
unnamed: D34.2 (A), SW34.1
unnamed: D35.2 (A), SW35.1
unnamed: D36.2 (A), SW36.1
unnamed: D37.2 (A), SW37.1
unnamed: D38.2 (A), SW38.1
unnamed: D39.2 (A), SW39.1
unnamed: D40.2 (A), SW40.1
unnamed: D41.2 (A), SW41.1
unnamed: D42.2 (A), SW42.1
unnamed: D43.2 (A), SW43.1
unnamed: D44.2 (A), SW44.1
unnamed: D45.2 (A), SW45.1
unnamed: D46.2 (A), SW46.1
unnamed: D47.2 (A), SW47.1
unnamed: D48.2 (A), SW48.1
unnamed: D49.2 (A), SW49.1
unnamed: D50.2 (A), SW50.1
unnamed: D51.2 (A), SW51.1
unnamed: D52.2 (A), SW52.1
unnamed: D53.2 (A), SW53.1
unnamed: D54.2 (A), SW54.1
unnamed: D55.2 (A), SW55.1
unnamed: D56.2 (A), SW56.1
unnamed: D57.2 (A), SW57.1
unnamed: D58.2 (A), SW58.1
unnamed: D59.2 (A), SW59.1
unnamed: D60.2 (A), SW60.1
unnamed: D61.2 (A), SW61.1
unnamed: D62.2 (A), SW62.1
unnamed: D63.2 (A), SW63.1
unnamed: D64.2 (A), SW64.1
unnamed: D65.2 (A), SW65.1
unnamed: D66.2 (A), SW66.1
unnamed: D67.2 (A), SW67.1
unnamed: D68.2 (A), SW68.1
unnamed: D69.2 (A), SW69.1
unnamed: D70.2 (A), SW70.1
unnamed: D71.2 (A), SW71.1
unnamed: D72.2 (A), SW72.1
unnamed: D73.2 (A), SW73.1
unnamed: D74.2 (A), SW74.1
unnamed: D75.2 (A), SW75.1
unnamed: D76.2 (A), SW76.1
unnamed: D77.2 (A), SW77.1
unnamed: D78.2 (A), SW78.1
unnamed: D79.2 (A), SW79.1
unnamed: D80.2 (A), SW80.1
unnamed: D81.2 (A), SW81.1
unnamed: D82.2 (A), SW82.1
unnamed: D83.2 (A), SW83.1
unnamed: D84.2 (A), SW84.1
unnamed: D85.2 (A), SW85.1
unnamed: D86.2 (A), SW86.1
unnamed: D87.2 (A), SW87.1
unnamed: D88.2 (A), SW88.1
unnamed: D89.2 (A), SW89.1
unnamed: D90.2 (A), SW90.1
unnamed: D91.2 (A), SW91.1
unnamed: D92.2 (A), SW92.1
unnamed: D93.2 (A), SW93.1
unnamed: D94.2 (A), SW94.1
unnamed: D95.2 (A), SW95.1
unnamed: D96.2 (A), SW96.1
unnamed: D97.2 (A), SW97.1
unnamed: D98.2 (A), SW98.1
unnamed: D99.2 (A), SW99.1
unnamed: D100.2 (A), SW100.1
unnamed: D101.2 (A), SW101.1
unnamed: D102.2 (A), SW102.1
unnamed: D103.2 (A), SW103.1
unnamed: D104.2 (A), SW104.1
unnamed: D105.2 (A), SW105.1
unnamed: D106.2 (A), SW106.1
unnamed: D107.2 (A), SW107.1
unnamed: D108.2 (A), SW108.1
unnamed: D109.2 (A), SW109.1
unnamed: D110.2 (A), SW110.1
unnamed: D111.2 (A), SW111.1
unnamed: D112.2 (A), SW112.1
unnamed: D113.1 (K), R7.1
unnamed: J1.A5 (CC1), R5.1
unnamed: J1.B5 (CC2), R6.1
unnamed: R8.2, U3.8 (PROG)
unnamed: C1.2, U4.B24 (XC1), Y1.1
unnamed: C2.1, U4.A23 (XC2), Y1.3
RESET: SW114.2, U4.AC13 (P0.18/~RESET)
RES_IN: R9.1, U4.B17 (P1.12)
RES_OUT: Q1.2 (B), R9.2
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), U4.Y23 (P1.01)
ROW1: D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), U4.W24 (P1.02)
ROW2: D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), U4.V23 (P1.03)
ROW3: D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), U4.U24 (P1.04)
ROW4: D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), U4.T23 (P1.05)
ROW5: D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D79.1 (K), D80.1 (K), D81.1 (K), D82.1 (K), D83.1 (K), D84.1 (K), U4.R24 (P1.06)
ROW6: D85.1 (K), D86.1 (K), D87.1 (K), D88.1 (K), D89.1 (K), D90.1 (K), D91.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), D95.1 (K), D96.1 (K), D97.1 (K), D98.1 (K), U4.P23 (P1.07)
ROW7: D99.1 (K), D100.1 (K), D101.1 (K), D102.1 (K), D103.1 (K), D104.1 (K), D105.1 (K), D106.1 (K), D107.1 (K), D108.1 (K), D109.1 (K), D110.1 (K), D111.1 (K), D112.1 (K), U4.P2 (P1.08)
SCL: U1.3 (SCL), U4.A16 (P1.13)
SDA: U1.4 (SDA), U4.B15 (P1.14)
STAT: D113.2 (A), U3.5 (STAT)
USB_D+: J1.A6 (D+), J1.B6 (D+), U2.3 (I/O2), U4.AD6 (D+)
USB_D-: J1.A7 (D-), J1.B7 (D-), U2.1 (I/O1), U4.AD4 (D-)
VBAT: J2.1, U3.3 (V_{BAT}), U3.4 (V_{BAT}), U4.Y2 (VDDH)
VBUS: C3.1, C4.1, D115.3 (VDD), F1.1, F1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U2.4 (I/O2), U3.1 (V_{DD}), U3.2 (V_{DD}), U4.AD2 (VBUS), U5.4, U5.10, U5.13, U5.14 (VCC); also elsewhere on the board
